# Keil uVision project serial_dialog_stuffing.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\source;.\source\startup;.\source\config;.\source\std_periph_lib;.\source\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group startup
    ./source/startup/: startup_stm32l1xx_md.s
  group config
    ./source/config/: stm32l1xx.h stm32l1xx_conf.h
  group std_periph_lib
    ./source/std_periph_lib/: misc.c misc.h stm32l1xx_adc.c stm32l1xx_adc.h stm32l1xx_aes.c stm32l1xx_aes.h stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_comp.h stm32l1xx_crc.c stm32l1xx_crc.h stm32l1xx_dac.c stm32l1xx_dac.h stm32l1xx_dbgmcu.c stm32l1xx_dbgmcu.h stm32l1xx_dma.c stm32l1xx_dma.h stm32l1xx_exti.c stm32l1xx_exti.h stm32l1xx_flash.c stm32l1xx_flash.h stm32l1xx_fsmc.c stm32l1xx_fsmc.h stm32l1xx_gpio.c stm32l1xx_gpio.h stm32l1xx_i2c.c stm32l1xx_i2c.h stm32l1xx_iwdg.c stm32l1xx_iwdg.h stm32l1xx_lcd.c stm32l1xx_lcd.h stm32l1xx_opamp.c stm32l1xx_opamp.h stm32l1xx_pwr.c stm32l1xx_pwr.h stm32l1xx_rcc.c stm32l1xx_rcc.h stm32l1xx_rtc.c stm32l1xx_rtc.h stm32l1xx_sdio.c stm32l1xx_sdio.h stm32l1xx_spi.c stm32l1xx_spi.h stm32l1xx_syscfg.c stm32l1xx_syscfg.h stm32l1xx_tim.c stm32l1xx_tim.h stm32l1xx_usart.c stm32l1xx_usart.h stm32l1xx_wwdg.c stm32l1xx_wwdg.h
  group CMSIS
    ./source/CMSIS/: core_cm3.c core_cm3.h system_stm32l1xx.c system_stm32l1xx.h
  group sources
    ./: main.c functions.c usart1_irq.c vars.c
